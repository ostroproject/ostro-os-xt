# Enable C++11 featuresa
# Upstream-status: Submitted[http://lists.openembedded.org/pipermail/openembedded-devel/2016-October/109561.html]
CXXFLAGS += "-std=c++11"

