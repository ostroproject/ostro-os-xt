FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Pass-linker-flags-LDFLAGS-to-compiler.patch"
