FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://CVE-2016-2180.patch \
    file://CVE-2016-6304.patch \
"
