FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://CVE-2016-5131-use-after-free-in-xpath.patch"
