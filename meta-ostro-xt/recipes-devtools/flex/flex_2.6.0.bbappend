FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://CVE-2016-6354.patch"
