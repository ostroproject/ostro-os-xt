FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://More-correctly-fix-xattrs.patch"
