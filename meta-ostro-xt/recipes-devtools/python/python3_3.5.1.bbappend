FILESEXTRAPATHS_prepend := "${THISDIR}/python3:"

SRC_URI_append = " file://CVE-2016-5636.patch"
