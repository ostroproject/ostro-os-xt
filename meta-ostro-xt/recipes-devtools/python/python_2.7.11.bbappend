FILESEXTRAPATHS_prepend := "${THISDIR}/python:"

SRC_URI_append = " file://CVE-2016-5636.patch"
