PACKAGECONFIG_append = " dri3"
