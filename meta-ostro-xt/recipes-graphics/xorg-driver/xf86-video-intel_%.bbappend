SRC_URI_remove = "file://disable-x11-dri3.patch"

PACKAGECONFIG_append = " dri3"
