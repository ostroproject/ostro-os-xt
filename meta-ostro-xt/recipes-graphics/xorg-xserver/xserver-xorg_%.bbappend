PACKAGECONFIG_append = " dri3 xshmfence"
