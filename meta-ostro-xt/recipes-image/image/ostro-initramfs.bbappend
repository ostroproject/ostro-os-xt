PACKAGE_INSTALL += "initramfs-framework-installer"
