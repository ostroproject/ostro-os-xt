SUMMARY = "Ostro OS XT image without swupd and with benchmarks and QA support."

IMAGE_FEATURES += " \
  benchmark \
  qatests \
"
inherit ostro-xt-image
