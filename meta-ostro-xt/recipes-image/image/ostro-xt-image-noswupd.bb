SUMMARY = "Ostro OS XT image for local builds without benchmarking, qa and swupd."

inherit ostro-xt-image
