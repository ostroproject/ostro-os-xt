RDEPENDS_${PN}-doc_remove = "man"
