DEPENDS_remove = "gstreamer1.0-plugins-bad"
