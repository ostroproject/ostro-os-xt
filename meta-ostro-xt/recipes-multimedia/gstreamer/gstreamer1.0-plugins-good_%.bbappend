PACKAGECONFIG_remove = "speex"
