DEPENDS += " alsa-lib libsndfile1"
