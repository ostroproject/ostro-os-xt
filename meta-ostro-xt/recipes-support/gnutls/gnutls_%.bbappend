FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://CVE-2016-7444.patch"
