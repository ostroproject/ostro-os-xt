DEPENDS_append = " krb5 e2fsprogs"
