# The code of libtiff is not of acceptable quality - disable it for now.
PACKAGECONFIG_remove = "tiff"

