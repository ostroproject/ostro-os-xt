FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-Remove-browser-mail-from-apllications-menu.patch"
