DEPENDS_remove = "intltool"
DEPENDS_append = " intltool-native"
