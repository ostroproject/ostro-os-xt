FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-Remove-stale-icons-from-panel.patch"
